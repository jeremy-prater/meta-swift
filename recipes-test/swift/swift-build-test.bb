DESCRIPTION = "swift 5.1.2 test application"
LICENSE = "CLOSED"

SRC_URI = "file://Sources/hello-world/main.swift \
           file://Package.swift \
"

inherit swift

